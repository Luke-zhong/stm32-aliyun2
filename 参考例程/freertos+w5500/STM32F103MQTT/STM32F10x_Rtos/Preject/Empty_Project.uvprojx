# Keil uVision project Empty_Project.uvprojx, settings and files
target Empty (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Empty_Project
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS\Startup;..\Libraries\CMSIS;..\Libraries\Periph_Driver\inc;..\User;..\FreeRTOS\include;..\word\usart;..\Ethernet\device;..\Ethernet\dns;..\Ethernet\socket;..\Ethernet\w5500;..\Ethernet;..\Ethernet\DHCP;..\Ethernet\spi;..\mqtt;..\word\user_mqtt
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start_up
    ../Libraries/CMSIS/Startup/: startup_stm32f10x_hd.s
  group cmsis
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group libraries
    ../Libraries/Periph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c stm32f10x_conf.h
  group freerots
    ../FreeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
  group word
    ../word/usart/: user_usart.c
    ../word/user_mqtt/: user_mqtt.c
  group ethernet
    ../Ethernet/socket/: socket.c
    ../Ethernet/w5500/: w5500.c
    ../Ethernet/dns/: dns.c
    ../Ethernet/: wizchip_conf.c
    ../Ethernet/DHCP/: dhcp.c
    ../Ethernet/spi/: spi2.c
  group mqtt
    ../mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
